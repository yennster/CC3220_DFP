# Keil uVision project dummy.uvprojx, settings and files
target MVCM3250 Flash (ARM-ADS)
  device: MVCM3250 Generic
  cpu: IROM(0x00000000,0x4000) IRAM(0x20000000,0x0800) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: dummy
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Source Files
    ./: main.c template1.c template2.c
  group ::Device
    RTE/Device/MVCM3250/: startup_mvcm3xxx.s system_mvcm3xxx.c
  group ::Drivers
    C:/Keilv510/ARM/PACK/MyVendor/MVCM3/0.0.1/Drivers/I2C/: I2C_MVCM3.c
    C:/Keilv510/ARM/PACK/MyVendor/MVCM3/0.0.1/Drivers/UART/: UART_MVCM3.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0, Drivers:I2C 1.0.0, Drivers:UART 1.0.0, MyVendor:MVCM3 User Code Templates 0.0.1
